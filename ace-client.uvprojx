# Keil uVision project ace-client.uvprojx, settings and files
target ace-client (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0CAJ12 NXP
  pack: NXP.MK64F12_DFP.10.0.4
  cpu: IRAM(0x14000000,0x1000) IRAM2(0x1fff0000,0x010000) IROM(0x00000000,0x100000) XRAM(0x20000000,0x030000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ace-client
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __MBED__
  c misc: -DTARGET_KSDK2_MCUS -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 --no_rtti -DTOOLCHAIN_ARM_STD -DTARGET_KPSDK_CODE --split_sections -DFEATURE_LWIP=1 -D__ASSERT_MSG -DDEVICE_CRC=1 -DTARGET_MCU_K64F -DDEVICE_LPTICKER=1 -DDEVICE_PORTINOUT=1 --multibyte_chars -g -DDEVICE_PWMOUT=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DTARGET_Freescale_EMAC -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_FLASH=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M4.fp -DTARGET_FRDM -DFEATURE_STORAGE=1 -DTARGET_LIKE_CORTEX_M4 -DARM_MATH_CM4 -DTARGET_CORTEX_M -DDEVICE_SERIAL=1 -DTARGET_KPSDK_MCUS -DTARGET_Freescale --restrict -DMBED_BUILD_TIMESTAMP=1533705687.74 -DDEVICE_USTICKER=1 -DDEVICE_I2C=1 -D__CORTEX_M4 --preinclude=mbed_config.h -DTARGET_CORTEX -DDEVICE_TRNG=1 -DTARGET_MCUXpresso_MCUS -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DDEVICE_ANALOGIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -D__CMSIS_RTOS --md -DDEVICE_EMAC=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu --brief_diagnostics -DTARGET_DEBUG -DFEATURE_COMMON_PAL=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DMBED_TRAP_ERRORS_ENABLED=1 -DTARGET_K64F -DCPU_MK64FN1M0VMD12 -DDEVICE_STORAGE=1 -DDEVICE_PORTIN=1 -DTARGET_M4 -DMBED_DEBUG -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -DFSL_RTOS_MBED -DDEVICE_SPI_ASYNCH=1 -D__MBED_CMSIS_RTOS_CM
  c include: .;cn-cbor;cose;easy-connect;easy-connect\atmel-rf-driver;easy-connect\atmel-rf-driver\atmel-rf-driver;easy-connect\atmel-rf-driver\source;easy-connect\esp8266-driver;easy-connect\esp8266-driver\ESP8266;easy-connect\mcr20a-rf-driver;easy-connect\mcr20a-rf-driver\mcr20a-rf-driver;easy-connect\mcr20a-rf-driver\source;easy-connect\stm-spirit1-rf-driver;easy-connect\stm-spirit1-rf-driver\source;easy-connect\stm-spirit1-rf-driver\source\libs;easy-connect\stm-spirit1-rf-driver\source\libs\Contiki_STM32_Library;easy-connect\stm-spirit1-rf-driver\source\libs\spirit1;easy-connect\stm-spirit1-rf-driver\source\libs\spirit1\SPIRIT1_Library;easy-connect\stm-spirit1-rf-driver\source\libs\spirit1\SPIRIT1_Library\Inc;easy-connect\stm-spirit1-rf-driver\source\libs\spirit1\SPIRIT1_Library\Src;easy-connect\stm-spirit1-rf-driver\source\libs\spirit1\X-NUCLEO-IDS01Ax;easy-connect\stm-spirit1-rf-driver\stm-spirit1-rf-driver;easy-connect\wifi-ism43362;easy-connect\wifi-ism43362\ISM43362;easy-connect\wifi-ism43362\ISM43362\ATParser;easy-connect\wifi-ism43362\ISM43362\ATParser\BufferedSpi;easy-connect\wifi-ism43362\ISM43362\ATParser\BufferedSpi\Buffer;easy-connect\wifi-x-nucleo-idw01m1;easy-connect\wifi-x-nucleo-idw01m1\SPWFSA01;easy-connect\wifi-x-nucleo-idw01m1\SPWFSA04;easy-connect\wizfi310-driver;easy-connect\wizfi310-driver\WizFi310;easy-connect\wnc14a2a-driver;easy-connect\wnc14a2a-driver\WNC14A2AInterface;easy-connect\wnc14a2a-driver\WNC14A2AInterface\WncControllerK64F;easy-connect\wnc14a2a-driver\WNC14A2AInterface\WncControllerK64F\WncController;mbed-os;mbed-os\cmsis;mbed-os\cmsis\TARGET_CORTEX_M;mbed-os\drivers;mbed-os\events;mbed-os\events\equeue;mbed-os\features;mbed-os\features\cellular;mbed-os\features\cellular\easy_cellular;mbed-os\features\cellular\framework;mbed-os\features\cellular\framework\API;mbed-os\features\cellular\framework\AT;mbed-os\features\cellular\framework\common;mbed-os\features\cellular\framework\targets;mbed-os\features\cellular\framework\targets\QUECTEL;mbed-os\features\cellular\framework\targets\QUECTEL\BC95;mbed-os\features\cellular\framework\targets\QUECTEL\BG96;mbed-os\features\cellular\framework\targets\QUECTEL\UG96;mbed-os\features\cellular\framework\targets\TELIT;mbed-os\features\cellular\framework\targets\TELIT\HE910;mbed-os\features\cellular\framework\targets\UBLOX;mbed-os\features\cellular\framework\targets\UBLOX\PPP;mbed-os\features\cryptocell;mbed-os\features\device_key;mbed-os\features\device_key\source;mbed-os\features\filesystem;mbed-os\features\filesystem\bd;mbed-os\features\filesystem\fat;mbed-os\features\filesystem\fat\ChaN;mbed-os\features\filesystem\littlefs;mbed-os\features\filesystem\littlefs\littlefs;mbed-os\features\frameworks;mbed-os\features\frameworks\greentea-client;mbed-os\features\frameworks\greentea-client\greentea-client;mbed-os\features\frameworks\greentea-client\source;mbed-os\features\frameworks\mbed-client-randlib;mbed-os\features\frameworks\mbed-client-randlib\mbed-client-randlib;mbed-os\features\frameworks\mbed-client-randlib\mbed-client-randlib\platform;mbed-os\features\frameworks\mbed-client-randlib\source;mbed-os\features\frameworks\mbed-coap;mbed-os\features\frameworks\mbed-coap\doxygen;mbed-os\features\frameworks\mbed-coap\mbed-coap;mbed-os\features\frameworks\mbed-coap\source;mbed-os\features\frameworks\mbed-coap\source\include;mbed-os\features\frameworks\mbed-trace;mbed-os\features\frameworks\mbed-trace\mbed-trace;mbed-os\features\frameworks\mbed-trace\source;mbed-os\features\frameworks\nanostack-libservice;mbed-os\features\frameworks\nanostack-libservice\mbed-client-libservice;mbed-os\features\frameworks\nanostack-libservice\mbed-client-libservice\platform;mbed-os\features\frameworks\nanostack-libservice\source;mbed-os\features\frameworks\nanostack-libservice\source\IPv6_fcf_lib;mbed-os\features\frameworks\nanostack-libservice\source\libBits;mbed-os\features\frameworks\nanostack-libservice\source\libip6string;mbed-os\features\frameworks\nanostack-libservice\source\libList;mbed-os\features\frameworks\nanostack-libservice\source\libTrace;mbed-os\features\frameworks\nanostack-libservice\source\libTrace\scripts;mbed-os\features\frameworks\nanostack-libservice\source\nsdynmemLIB;mbed-os\features\frameworks\nanostack-libservice\source\nvmHelper;mbed-os\features\frameworks\unity;mbed-os\features\frameworks\unity\source;mbed-os\features\frameworks\unity\unity;mbed-os\features\frameworks\utest;mbed-os\features\frameworks\utest\source;mbed-os\features\frameworks\utest\utest;mbed-os\features\lorawan;mbed-os\features\lorawan\lorastack;mbed-os\features\lorawan\lorastack\mac;mbed-os\features\lorawan\lorastack\phy;mbed-os\features\lorawan\system;mbed-os\features\mbedtls;mbed-os\features\mbedtls\importer;mbed-os\features\mbedtls\inc;mbed-os\features\mbedtls\inc\mbedtls;mbed-os\features\mbedtls\platform;mbed-os\features\mbedtls\platform\inc;mbed-os\features\mbedtls\platform\src;mbed-os\features\mbedtls\src;mbed-os\features\mbedtls\targets;mbed-os\features\nanostack;mbed-os\features\nanostack\coap-service;mbed-os\features\nanostack\coap-service\coap-service;mbed-os\features\nanostack\coap-service\source;mbed-os\features\nanostack\coap-service\source\include;mbed-os\features\nanostack\mbed-mesh-api;mbed-os\features\nanostack\mbed-mesh-api\mbed-mesh-api;mbed-os\features\nanostack\mbed-mesh-api\source;mbed-os\features\nanostack\mbed-mesh-api\source\include;mbed-os\features\nanostack\nanostack-hal-mbed-cmsis-rtos;mbed-os\features\nanostack\nanostack-hal-mbed-cmsis-rtos\cs_nvm;mbed-os\features\nanostack\nanostack-hal-mbed-cmsis-rtos\nvm;mbed-os\features\nanostack\nanostack-interface;mbed-os\features\nanostack\sal-stack-nanostack;mbed-os\features\nanostack\sal-stack-nanostack\docs;mbed-os\features\nanostack\sal-stack-nanostack\docs\img;mbed-os\features\nanostack\sal-stack-nanostack\doxygen;mbed-os\features\nanostack\sal-stack-nanostack\nanostack;mbed-os\features\nanostack\sal-stack-nanostack\nanostack\platform;mbed-os\features\nanostack\sal-stack-nanostack\source;mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN;mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\Bootstraps;mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\Bootstraps\Generic;mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\Fragmentation;mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\IPHC_Decode;mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\MAC;mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\Mesh;mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\ND;mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\NVM;mbed-os\features\nanostack\sal-stack-nanostack\source\6LoWPAN\Thread;mbed-os\features\nanostack\sal-stack-nanostack\source\BorderRouter;mbed-os\features\nanostack\sal-stack-nanostack\source\Common_Protocols;mbed-os\features\nanostack\sal-stack-nanostack\source\configs;mbed-os\features\nanostack\sal-stack-nanostack\source\configs\base;mbed-os\features\nanostack\sal-stack-nanostack\source\Core;mbed-os\features\nanostack\sal-stack-nanostack\source\Core\include;mbed-os\features\nanostack\sal-stack-nanostack\source\DHCPv6_Server;mbed-os\features\nanostack\sal-stack-nanostack\source\ipv6_stack;mbed-os\features\nanostack\sal-stack-nanostack\source\libDHCPv6;mbed-os\features\nanostack\sal-stack-nanostack\source\libNET;mbed-os\features\nanostack\sal-stack-nanostack\source\libNET\src;mbed-os\features\nanostack\sal-stack-nanostack\source\MAC;mbed-os\features\nanostack\sal-stack-nanostack\source\MAC\ethernet;mbed-os\features\nanostack\sal-stack-nanostack\source\MAC\IEEE802_15_4;mbed-os\features\nanostack\sal-stack-nanostack\source\MAC\serial;mbed-os\features\nanostack\sal-stack-nanostack\source\MAC\virtual_rf;mbed-os\features\nanostack\sal-stack-nanostack\source\MLE;mbed-os\features\nanostack\sal-stack-nanostack\source\MPL;mbed-os\features\nanostack\sal-stack-nanostack\source\NWK_INTERFACE;mbed-os\features\nanostack\sal-stack-nanostack\source\NWK_INTERFACE\Include;mbed-os\features\nanostack\sal-stack-nanostack\source\RPL;mbed-os\features\nanostack\sal-stack-nanostack\source\Security;mbed-os\features\nanostack\sal-stack-nanostack\source\Security\Common;mbed-os\features\nanostack\sal-stack-nanostack\source\Security\PANA;mbed-os\features\nanostack\sal-stack-nanostack\source\Security\TLS;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\blacklist;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\CCM_lib;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\CCM_lib\mbedOS;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\etx;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\fhss;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\fnv_hash;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\load_balance;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\port;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\port\compiler;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\port\cpu;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services\dns;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services\mdns;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services\poll;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\services\serial;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mdns\fnet\fnet_stack\stack;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\mle_service;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\nd_proxy;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\Neighbor_cache;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\pan_blacklist;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\SHA256_Lib;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\Trickle;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\utils;mbed-os\features\nanostack\sal-stack-nanostack\source\Service_Libs\whiteboard;mbed-os\features\nanostack\sal-stack-nanostack-eventloop;mbed-os\features\nanostack\sal-stack-nanostack-eventloop\nanostack-event-loop;mbed-os\features\nanostack\sal-stack-nanostack-eventloop\nanostack-event-loop\platform;mbed-os\features\nanostack\sal-stack-nanostack-eventloop\source;mbed-os\features\nanostack\targets;mbed-os\features\netsocket;mbed-os\features\netsocket\cellular;mbed-os\features\netsocket\cellular\generic_modem_driver;mbed-os\features\netsocket\emac-drivers;mbed-os\features\netsocket\emac-drivers\TARGET_Freescale_EMAC;mbed-os\features\netsocket\emac-drivers\TARGET_Freescale_EMAC\TARGET_K64F;mbed-os\features\nvstore;mbed-os\features\nvstore\source;mbed-os\features\storage;mbed-os\hal;mbed-os\hal\storage_abstraction;mbed-os\platform;mbed-os\rtos;mbed-os\rtos\TARGET_CORTEX;mbed-os\rtos\TARGET_CORTEX\rtx4;mbed-os\rtos\TARGET_CORTEX\rtx5;mbed-os\rtos\TARGET_CORTEX\rtx5\Include;mbed-os\rtos\TARGET_CORTEX\rtx5\RTX;mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Config;mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Include;mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Source;mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Source\TOOLCHAIN_ARM;mbed-os\rtos\TARGET_CORTEX\rtx5\RTX\Source\TOOLCHAIN_ARM\TARGET_RTOS_M4_M7;mbed-os\rtos\TARGET_CORTEX\rtx5\Source;mbed-os\rtos\TARGET_CORTEX\TARGET_CORTEX_M;mbed-os\rtos\TARGET_CORTEX\TARGET_CORTEX_M\TOOLCHAIN_ARM;mbed-os\targets;mbed-os\targets\TARGET_Freescale;mbed-os\targets\TARGET_Freescale\TARGET_MCUXpresso_MCUS;mbed-os\targets\TARGET_Freescale\TARGET_MCUXpresso_MCUS\api;mbed-os\targets\TARGET_Freescale\TARGET_MCUXpresso_MCUS\TARGET_MCU_K64F;mbed-os\targets\TARGET_Freescale\TARGET_MCUXpresso_MCUS\TARGET_MCU_K64F\device;mbed-os\targets\TARGET_Freescale\TARGET_MCUXpresso_MCUS\TARGET_MCU_K64F\device\TOOLCHAIN_ARM_STD;mbed-os\targets\TARGET_Freescale\TARGET_MCUXpresso_MCUS\TARGET_MCU_K64F\drivers;mbed-os\targets\TARGET_Freescale\TARGET_MCUXpresso_MCUS\TARGET_MCU_K64F\TARGET_FRDM;mbed-os\features\FEATURE_LWIP;mbed-os\features\FEATURE_LWIP\lwip-interface;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src\api;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src\core;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src\core\ipv4;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src\core\ipv6;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src\include;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src\include\lwip;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src\include\lwip\priv;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src\include\lwip\prot;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src\include\netif;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src\include\netif\ppp;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src\include\netif\ppp\polarssl;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src\netif;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src\netif\ppp;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip\src\netif\ppp\polarssl;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip-sys;mbed-os\features\FEATURE_LWIP\lwip-interface\lwip-sys\arch;mbed-os\features\storage\FEATURE_STORAGE;mbed-os\features\storage\FEATURE_STORAGE\cfstore;mbed-os\features\storage\FEATURE_STORAGE\cfstore\configuration-store;mbed-os\features\storage\FEATURE_STORAGE\cfstore\doc;mbed-os\features\storage\FEATURE_STORAGE\cfstore\doc\design;mbed-os\features\storage\FEATURE_STORAGE\cfstore\doc\design\pics;mbed-os\features\storage\FEATURE_STORAGE\cfstore\doc\design\umlet;mbed-os\features\storage\FEATURE_STORAGE\cfstore\doc\project;mbed-os\features\storage\FEATURE_STORAGE\cfstore\source;mbed-os\features\storage\FEATURE_STORAGE\flash-journal;mbed-os\features\storage\FEATURE_STORAGE\flash-journal\flash-journal-strategy-sequential;mbed-os\features\storage\FEATURE_STORAGE\storage-volume-manager;mbed-os\features\storage\FEATURE_STORAGE\storage-volume-manager\source;mbed-os\features\storage\FEATURE_STORAGE\storage-volume-manager\storage-volume-manager
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CORTEX_M4,-DCPU_MK64FN1M0VMD12,-DARM_MATH_CM4,-D__FPU_PRESENT=1,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS,-DFSL_RTOS_MBED
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: ROM 0x20000000 size 0x30000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: .\.link_script.sct
  link misc: --show_full_path
  group ace-client
    ./: ace.cpp ace.h cn-cbor-aux.c cn-cbor-aux.h hkdf.c hkdf.h main.cpp mbed_config.h oscore.cpp oscore.h link-mem.c link-mem.h
  group cn-cbor
    ./cn-cbor/: cbor.h cn-cbor.c cn-cbor.h cn-create.c cn-encoder.c cn-error.c cn-get.c cn-print.c dll-export.h
  group cose
    ./cose/: cbor.c configure.h Cose.c cose.h cose_int.h crypto.h Encrypt.c Encrypt0.c MacMessage.c MacMessage0.c mbedtls.c Recipient.c Sign.c Sign0.c SignerInfo.c
  group easy-connect
    ./easy-connect/atmel-rf-driver/source/: at24mac.cpp at24mac.h AT86RFReg.h NanostackRfPhyAtmel.cpp
    ./easy-connect/wifi-ism43362/ISM43362/ATParser/: ATParser.cpp ATParser.h
    ./easy-connect/wifi-x-nucleo-idw01m1/: BlockExecuter.h SpwfSAInterface.cpp SpwfSAInterface.h SPWFSAxx.cpp SPWFSAxx.h
    ./easy-connect/wifi-ism43362/ISM43362/ATParser/BufferedSpi/: BufferedPrint.c BufferedSpi.cpp BufferedSpi.h
    ./easy-connect/stm-spirit1-rf-driver/source/libs/Contiki_STM32_Library/: contiki-conf.h hw-config.h ip64-conf.h platform-conf.h radio.h spirit1-config.h spirit1-const.h spirit1.h stm32l-spirit1-config.h
    ./easy-connect/: easy-connect.cpp easy-connect.h
    ./easy-connect/esp8266-driver/ESP8266/: ESP8266.cpp ESP8266.h
    ./easy-connect/esp8266-driver/: ESP8266Interface.cpp ESP8266Interface.h
    ./easy-connect/wifi-ism43362/ISM43362/: ISM43362.cpp ISM43362.h
    ./easy-connect/wifi-ism43362/: ISM43362Interface.cpp ISM43362Interface.h
    ./easy-connect/mcr20a-rf-driver/source/: MCR20Drv.c MCR20Drv.h MCR20Overwrites.h MCR20Reg.h NanostackRfPhyMcr20a.cpp XcvrSpi.h
    ./easy-connect/stm-spirit1-rf-driver/source/libs/spirit1/SPIRIT1_Library/Inc/: MCU_Interface.h SPIRIT_Aes.h SPIRIT_Calibration.h SPIRIT_Commands.h SPIRIT_Config.h SPIRIT_Csma.h SPIRIT_DirectRF.h SPIRIT_General.h SPIRIT_Gpio.h SPIRIT_Irq.h SPIRIT_LinearFifo.h SPIRIT_Management.h SPIRIT_PktBasic.h SPIRIT_PktCommon.h SPIRIT_PktMbus.h SPIRIT_PktStack.h SPIRIT_Qi.h SPIRIT_Radio.h SPIRIT_Regs.h SPIRIT_Timer.h SPIRIT_Types.h
    ./easy-connect/wifi-ism43362/ISM43362/ATParser/BufferedSpi/Buffer/: MyBuffer.cpp MyBuffer.h
    ./easy-connect/atmel-rf-driver/atmel-rf-driver/: NanostackRfPhyAtmel.h
    ./easy-connect/mcr20a-rf-driver/mcr20a-rf-driver/: NanostackRfPhyMcr20a.h
    ./easy-connect/stm-spirit1-rf-driver/source/: NanostackRfPhySpirit1.cpp radio_spi.cpp SimpleSpirit1.cpp
    ./easy-connect/stm-spirit1-rf-driver/stm-spirit1-rf-driver/: NanostackRfPhySpirit1.h radio_spi.h SimpleSpirit1.h
    ./easy-connect/stm-spirit1-rf-driver/source/libs/spirit1/X-NUCLEO-IDS01Ax/: radio_gpio.h radio_shield_config.h
    ./easy-connect/stm-spirit1-rf-driver/source/libs/spirit1/SPIRIT1_Library/Src/: SPIRIT_Aes.c SPIRIT_Calibration.c SPIRIT_Commands.c SPIRIT_Csma.c SPIRIT_DirectRF.c SPIRIT_General.c SPIRIT_Gpio.c SPIRIT_Irq.c SPIRIT_LinearFifo.c SPIRIT_Management.c SPIRIT_PktBasic.c SPIRIT_PktCommon.c SPIRIT_PktMbus.c SPIRIT_PktStack.c SPIRIT_Qi.c SPIRIT_Radio.c SPIRIT_Timer.c SPIRIT_Types.c
    ./easy-connect/wifi-x-nucleo-idw01m1/SPWFSA01/: SPWFSA01.cpp SPWFSA01.h spwfsa01_at_strings.h
    ./easy-connect/wifi-x-nucleo-idw01m1/SPWFSA04/: SPWFSA04.cpp SPWFSA04.h spwfsa04_at_strings.h
    ./easy-connect/wizfi310-driver/WizFi310/: WizFi310.cpp WizFi310.h
    ./easy-connect/wizfi310-driver/: WizFi310Interface.cpp WizFi310Interface.h
    ./easy-connect/wnc14a2a-driver/WNC14A2AInterface/: WNC14A2AInterface.cpp WNC14A2AInterface.h WNCDebug.h WNCIO.h
    ./easy-connect/wnc14a2a-driver/WNC14A2AInterface/WncControllerK64F/WncController/: WncController.cpp WncController.h
    ./easy-connect/wnc14a2a-driver/WNC14A2AInterface/WncControllerK64F/: WncControllerK64F.cpp WncControllerK64F.h
  group mbed-os
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/IPHC_Decode/: 6lowpan_iphc.c cipv6.h iphc_compress.c iphc_compress.h iphc_decompress.c iphc_decompress.h lowpan_context.c lowpan_context.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/: adaptation_interface.c lowpan_adaptation_interface.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Core/: address.c buffer_dyn.c ns_socket.c sockbuf.c
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Core/include/: address.h ns_buffer.h ns_error_types.h sockbuf.h socket.h
    ./mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ./mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h aria.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config-no-entropy.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h platform_time.h platform_util.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/CCM_lib/mbedOS/: aes_mbedtls_adapter.c
    ./mbed-os/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.cpp Ethernet.h FlashIAP.cpp FlashIAP.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.cpp MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SerialWireOutput.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h TableCRC.cpp TableCRC.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h UARTSerial.cpp UARTSerial.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/api/: analogin_api.c analogout_api.c dma_api.c dma_api_hal.h flash_api.c gpio_api.c gpio_irq_api.c gpio_object.h i2c_api.c lp_ticker.c objects.h PeripheralPins.h pinmap.c port_api.c PortNames.h rtc_api.c sleep.c
    ./mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h lp_ticker_api.h mbed_critical_section_api.c mbed_flash_api.c mbed_gpio.c mbed_itm_api.c mbed_lp_ticker_api.c mbed_lp_ticker_wrapper.cpp mbed_pinmap_common.c mbed_sleep_manager.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip_addr.h lwip_errno.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h nd6_priv.h tcp_priv.h tcpip_priv.h
    ./mbed-os/features/cellular/easy_cellular/: APN_db.h CellularConnectionFSM.cpp CellularConnectionFSM.h EasyCellularConnection.cpp EasyCellularConnection.h
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/nanostack/platform/: arm_hal_aes.h arm_hal_phy.h os_whiteboard.h topo_trace.h
    ./mbed-os/features/nanostack/nanostack-hal-mbed-cmsis-rtos/: arm_hal_interrupt.c arm_hal_interrupt_private.h arm_hal_random.c arm_hal_timer.cpp ns_event_loop.c ns_event_loop.h ns_event_loop_mbed.cpp ns_event_loop_mutex.c ns_event_loop_mutex.h ns_hal_init.c ns_hal_init.h
    ./mbed-os/features/frameworks/nanostack-libservice/mbed-client-libservice/platform/: arm_hal_interrupt.h arm_hal_nvm.h
    ./mbed-os/features/frameworks/mbed-client-randlib/mbed-client-randlib/platform/: arm_hal_random.h
    ./mbed-os/features/nanostack/sal-stack-nanostack-eventloop/nanostack-event-loop/platform/: arm_hal_timer.h eventloop_config.h
    ./mbed-os/cmsis/TARGET_CORTEX_M/: arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_cmSecureAccess.h core_sc000.h core_sc300.h mbed_tz_context.c mpu_armv7.h mpu_armv8.h tz_context.h
    ./mbed-os/features/cellular/framework/AT/: AT_CellularBase.cpp AT_CellularBase.h AT_CellularDevice.cpp AT_CellularDevice.h AT_CellularInformation.cpp AT_CellularInformation.h AT_CellularNetwork.cpp AT_CellularNetwork.h AT_CellularPower.cpp AT_CellularPower.h AT_CellularSIM.cpp AT_CellularSIM.h AT_CellularSMS.cpp AT_CellularSMS.h AT_CellularStack.cpp AT_CellularStack.h ATHandler.cpp ATHandler.h
    ./mbed-os/platform/: ATCmdParser.cpp ATCmdParser.h Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h DeepSleepLock.h DirHandle.h FileBase.cpp FileBase.h FileHandle.cpp FileHandle.h FileLike.h FilePath.cpp FilePath.h FileSystemHandle.cpp FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.cpp LocalFileSystem.h mbed_alloc_wrappers.cpp mbed_application.c mbed_application.h mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_critical.h mbed_debug.h mbed_error.c mbed_error.h mbed_error_hist.c mbed_error_hist.h mbed_interface.c mbed_interface.h mbed_mem_trace.cpp mbed_mem_trace.h mbed_mktime.c mbed_mktime.h mbed_poll.cpp mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.cpp mbed_retarget.h mbed_rtc_time.cpp mbed_rtc_time.h mbed_sdk_boot.c mbed_semihost_api.c mbed_semihost_api.h mbed_sleep.h mbed_stats.c mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h semihost_api.h SingletonPtr.h sleep.h Stream.cpp Stream.h toolchain.h Transaction.h wait_api.h
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/prot/: autoip.h dhcp.h dns.h etharp.h icmp.h icmp6.h igmp.h ip.h ip4.h ip6.h lwip_ethernet.h mld6.h nd6.h tcp.h udp.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/MAC/: beacon_handler.c beacon_handler.h mac_data_poll.c mac_data_poll.h mac_helper.c mac_helper.h mac_pairwise_key.c mac_pairwise_key.h mac_response_handler.c mac_response_handler.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/blacklist/: blacklist.c blacklist.h
    ./mbed-os/features/filesystem/bd/: BlockDevice.h BufferedBlockDevice.cpp BufferedBlockDevice.h ChainingBlockDevice.cpp ChainingBlockDevice.h ExhaustibleBlockDevice.cpp ExhaustibleBlockDevice.h FlashSimBlockDevice.cpp FlashSimBlockDevice.h HeapBlockDevice.cpp HeapBlockDevice.h MBRBlockDevice.cpp MBRBlockDevice.h ObservingBlockDevice.cpp ObservingBlockDevice.h ProfilingBlockDevice.cpp ProfilingBlockDevice.h ReadOnlyBlockDevice.cpp ReadOnlyBlockDevice.h SlicingBlockDevice.cpp SlicingBlockDevice.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/BorderRouter/: border_router.c border_router.h
    ./mbed-os/features/nanostack/mbed-mesh-api/source/include/: callback_handler.h enet_tasklet.h mesh_system.h NanostackMemoryManager.h nd_tasklet.h thread_tasklet.h
    ./mbed-os/features/nanostack/mbed-mesh-api/source/: CallbackHandler.cpp ethernet_tasklet.c LoWPANNDInterface.cpp mesh_system.c MeshInterfaceNanostack.cpp NanostackEMACInterface.cpp NanostackEthernetInterface.cpp NanostackMemoryManager.cpp nd_tasklet.c thread_tasklet.c ThreadInterface.cpp
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/arch/: cc.h lwip_checksum.c lwip_memcpy.c lwip_sys_arch.c perf.h sys_arch.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/nanostack/: cca_api.h ccmLIB.h dhcp_service_api.h ethernet_mac_api.h fhss_api.h fhss_config.h mac_api.h mac_common_defines.h mac_filter_api.h mac_mcps.h mlme.h multicast_api.h net_6lowpan_parameter_api.h net_address_extension.h net_fhss.h net_interface.h net_ipv6_api.h net_load_balance_api.h net_mle_api.h net_nvm_api.h net_nwk_scan.h net_pana_parameters_api.h net_polling_api.h net_rpl.h net_sleep.h net_test_api.h net_thread_test.h ns_address.h ns_file_system.h ns_mdns_api.h ns_sha256.h ns_virtual_rf_api.h nwk_stats_api.h serial_mac_api.h shalib.h socket_api.h sw_mac.h thread_bbr_api.h thread_border_router_api.h thread_commissioning_api.h thread_dhcpv6_server.h thread_diagcop_lib.h thread_lowpower_api.h thread_management_api.h thread_management_if.h thread_meshcop_lib.h thread_net_config_api.h whiteboard_api.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/CCM_lib/: ccm_security.c
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
    ./mbed-os/features/netsocket/: CellularBase.h DNS.h EMAC.h EMACInterface.cpp EMACInterface.h EMACMemoryManager.cpp EMACMemoryManager.h EthernetInterface.cpp EthernetInterface.h EthInterface.h MeshInterface.h NetworkInterface.cpp NetworkInterface.h NetworkInterfaceDefaults.cpp NetworkStack.cpp NetworkStack.h nsapi.h nsapi_dns.cpp nsapi_dns.h nsapi_ppp.h nsapi_types.h OnboardNetworkStack.h Socket.cpp Socket.h SocketAddress.cpp SocketAddress.h TCPServer.cpp TCPServer.h TCPSocket.cpp TCPSocket.h UDPSocket.cpp UDPSocket.h WiFiAccessPoint.cpp WiFiAccessPoint.h WiFiInterface.h
    ./mbed-os/features/cellular/framework/common/: CellularCommon.h CellularList.h CellularLog.cpp CellularLog.h CellularTargets.h CellularUtil.cpp CellularUtil.h
    ./mbed-os/features/cellular/framework/API/: CellularDevice.h CellularInformation.h CellularNetwork.h CellularPower.h CellularSIM.h CellularSMS.h
    ./mbed-os/features/storage/FEATURE_STORAGE/cfstore/source/: cfstore_config.h cfstore_debug.h cfstore_fnmatch.c cfstore_fnmatch.h cfstore_list.h cfstore_svm.cpp cfstore_svm.h cfstore_test.c cfstore_test.h cfstore_utest.h cfstore_uvisor.h configuration_store.c
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/fhss/: channel_list.c channel_list.h fhss.c fhss.h fhss_beacon.c fhss_beacon.h fhss_beacon_tasklet.c fhss_channel.c fhss_channel.h fhss_configuration_interface.c fhss_mac_interface.c fhss_mac_interface.h fhss_statistics.c fhss_statistics.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Fragmentation/: cipv6_fragmenter.c cipv6_fragmenter.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device/: cmsis.h cmsis_nvic.h fsl_device_registers.h MK64F12.h MK64F12_features.h system_MK64F12.c system_MK64F12.h
    ./mbed-os/rtos/TARGET_CORTEX/rtx4/: cmsis_os.h cmsis_os1.c
    ./mbed-os/rtos/TARGET_CORTEX/rtx5/Include/: cmsis_os2.h os_tick.h
    ./mbed-os/features/nanostack/coap-service/source/: coap_connection_handler.c coap_message_handler.c coap_security_handler.c coap_service_api.c
    ./mbed-os/features/nanostack/coap-service/source/include/: coap_connection_handler.h coap_message_handler.h coap_security_handler.h coap_service_api_internal.h
    ./mbed-os/features/nanostack/coap-service/coap-service/: coap_service_api.h
    ./mbed-os/features/frameworks/nanostack-libservice/source/libBits/: common_functions.c
    ./mbed-os/features/frameworks/nanostack-libservice/mbed-client-libservice/: common_functions.h ip6string.h ip_fsc.h ns_list.h ns_nvm_helper.h ns_trace.h ns_types.h nsdynmemLIB.h
    ./mbed-os/rtos/: ConditionVariable.cpp ConditionVariable.h EventFlags.cpp EventFlags.h Kernel.cpp Kernel.h Mail.h MemoryPool.h Mutex.cpp Mutex.h Queue.h rtos.h rtos_idle.h RtosTimer.cpp RtosTimer.h Semaphore.cpp Semaphore.h Thread.cpp Thread.h
    ./mbed-os/features/storage/FEATURE_STORAGE/cfstore/configuration-store/: configuration_store.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/TARGET_FRDM/: crc.c crc.h device.h fsl_clock_config.c fsl_clock_config.h fsl_phy.c fsl_phy.h mbed_overrides.c PeripheralNames.h PeripheralPins.c PinNames.h
    ./mbed-os/features/nanostack/nanostack-hal-mbed-cmsis-rtos/cs_nvm/: cs_nvm.c
    ./mbed-os/features/device_key/source/: DeviceKey.cpp DeviceKey.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/libDHCPv6/: dhcp_service_api.c libDHCPv6.c libDHCPv6.h libDHCPv6_server.c libDHCPv6_server.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/DHCPv6_Server/: DHCPv6_Server_service.c DHCPv6_server_service.h
    ./mbed-os/features/filesystem/: Dir.cpp Dir.h File.cpp File.h FileSystem.cpp FileSystem.h mbed_filesystem.h
    ./mbed-os/features/filesystem/fat/ChaN/: diskio.h ff.cpp ff.h ffconf.h ffunicode.cpp integer.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/: dma_reqs.h mbed_crc_api.c peripheral_clock_defines.h pwmout_api.c serial_api.c spi_api.c storage_driver.c trng_api.c us_ticker.c
    ./mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Security/PANA/: eap_protocol.c eap_protocol.h pana.c pana.h pana_avp.c pana_avp.h pana_client.c pana_eap_header.c pana_eap_header.h pana_header.c pana_header.h pana_internal_api.h pana_nvm.h pana_relay_table.c pana_relay_table.h pana_server.c
    ./mbed-os/events/equeue/: equeue.c equeue.h equeue_mbed.cpp equeue_platform.h equeue_posix.c
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/: etharp.h lowpan6.h lowpan6_opts.h lwip_ethernet.h slipif.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/MAC/ethernet/: ethernet_mac_api.c
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/etx/: etx.c etx.h
    ./mbed-os/features/nanostack/sal-stack-nanostack-eventloop/source/: event.c event.h minar_hal_timer.cpp ns_timeout.c ns_timer.c ns_timer.h system_timer.c timer_sys.h
    ./mbed-os/events/: Event.h EventQueue.cpp EventQueue.h mbed_events.h mbed_shared_queues.cpp mbed_shared_queues.h
    ./mbed-os/features/nanostack/sal-stack-nanostack-eventloop/nanostack-event-loop/: eventOS_callback_timer.h eventOS_event.h eventOS_event_timer.h eventOS_scheduler.h
    ./mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/TOOLCHAIN_ARM/: except.S
    ./mbed-os/features/filesystem/fat/: FATFileSystem.cpp FATFileSystem.h
    ./mbed-os/features/storage/FEATURE_STORAGE/flash-journal/: flash_journal.h
    ./mbed-os/features/storage/FEATURE_STORAGE/flash-journal/flash-journal-strategy-sequential/: flash_journal_crc.c flash_journal_crc.h flash_journal_private.h flash_journal_strategy_sequential.h strategy.c support_funcs.c support_funcs.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/: fnet.h fnet_config.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/stack/: fnet_arp.h fnet_assert.h fnet_debug.h fnet_error.h fnet_eth.h fnet_icmp6.h fnet_inet.h fnet_ip.h fnet_ip6.h fnet_isr.h fnet_mempool.h fnet_nd6.h fnet_netbuf.h fnet_netif.h fnet_netif_prv.h fnet_socket.h fnet_stack.h fnet_stack_config.h fnet_stdlib.c fnet_stdlib.h fnet_timer.h fnet_timer_prv.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port/compiler/: fnet_comp.h fnet_comp_config.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/port/cpu/: fnet_cpu.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/dns/: fnet_dns.h fnet_dns_config.h fnet_dns_prv.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/mdns/: fnet_mdns.c fnet_mdns.h fnet_mdns_config.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/poll/: fnet_poll.c fnet_poll.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/serial/: fnet_serial.h fnet_serial_config.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/fnet/fnet_stack/services/: fnet_services.h fnet_services_config.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mdns/: fnet_user_config.h ns_fnet_events.c ns_fnet_events.h ns_fnet_port.c ns_fnet_types.h ns_mdns_api.c
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/fnv_hash/: fnv_hash.c fnv_hash.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/drivers/: fsl_adc16.c fsl_adc16.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_cmt.c fsl_cmt.h fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.c fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lptmr.c fsl_lptmr.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rnga.c fsl_rnga.h fsl_rtc.c fsl_rtc.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_sdhc.c fsl_sdhc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/: fsl_common.c
    ./mbed-os/features/frameworks/greentea-client/source/: greentea_metrics.cpp greentea_serial.cpp greentea_test_env.cpp
    ./mbed-os/features/frameworks/greentea-client/greentea-client/: greentea_metrics.h greentea_serial.h test_env.h
    ./mbed-os/features/netsocket/emac-drivers/TARGET_Freescale_EMAC/TARGET_K64F/: hardware_init_MK64F12.c
    ./mbed-os/features/mbedtls/targets/: hash_wrappers.c
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Common_Protocols/: icmpv6.c icmpv6.h icmpv6_prefix.c icmpv6_prefix.h icmpv6_radv.c icmpv6_radv.h ip.h ipv6.c ipv6.h ipv6_constants.h ipv6_flow.c ipv6_flow.h ipv6_fragmentation.c ipv6_fragmentation.h ipv6_resolution.c ipv6_resolution.h mld.c mld.h tcp.c tcp.h udp.c udp.h
    ./mbed-os/features/frameworks/nanostack-libservice/source/libip6string/: ip6tos.c stoip6.c
    ./mbed-os/features/frameworks/nanostack-libservice/source/IPv6_fcf_lib/: ip_fsc.c
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/ipv6_stack/: ipv6_routing_table.c ipv6_routing_table.h protocol_ipv6.c protocol_ipv6.h
    ./mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/TOOLCHAIN_ARM/TARGET_RTOS_M4_M7/: irq_cm4f.S
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/utils/: isqrt.c isqrt.h ns_crc.c ns_crc.h ns_file_system.c
    ./mbed-os/features/netsocket/emac-drivers/TARGET_Freescale_EMAC/: kinetis_emac.cpp kinetis_emac.h kinetis_emac_config.h
    ./mbed-os/features/filesystem/littlefs/littlefs/: lfs.c lfs.h lfs_util.c lfs_util.h
    ./mbed-os/features/filesystem/littlefs/: LittleFileSystem.cpp LittleFileSystem.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/load_balance/: load_balance.c load_balance_api.h
    ./mbed-os/features/lorawan/lorastack/phy/: lora_phy_ds.h LoRaPHY.cpp LoRaPHY.h loraphy_target.h LoRaPHYAS923.cpp LoRaPHYAS923.h LoRaPHYAU915.cpp LoRaPHYAU915.h LoRaPHYCN470.cpp LoRaPHYCN470.h LoRaPHYCN779.cpp LoRaPHYCN779.h LoRaPHYEU433.cpp LoRaPHYEU433.h LoRaPHYEU868.cpp LoRaPHYEU868.h LoRaPHYIN865.cpp LoRaPHYIN865.h LoRaPHYKR920.cpp LoRaPHYKR920.h LoRaPHYUS915.cpp LoRaPHYUS915.h LoRaPHYUS915Hybrid.cpp LoRaPHYUS915Hybrid.h
    ./mbed-os/features/lorawan/lorastack/mac/: LoRaMac.cpp LoRaMac.h LoRaMacChannelPlan.cpp LoRaMacChannelPlan.h LoRaMacCommand.cpp LoRaMacCommand.h LoRaMacCrypto.cpp LoRaMacCrypto.h
    ./mbed-os/features/lorawan/: LoRaRadio.h lorawan_types.h LoRaWANBase.h LoRaWANInterface.cpp LoRaWANInterface.h LoRaWANStack.cpp LoRaWANStack.h
    ./mbed-os/features/lorawan/system/: lorawan_data_structures.h LoRaWANTimer.cpp LoRaWANTimer.h
    ./mbed-os/features/nanostack/mbed-mesh-api/mbed-mesh-api/: LoWPANNDInterface.h mesh_interface_types.h MeshInterfaceNanostack.h NanostackEMACInterface.h NanostackEthernetInterface.h NanostackRfInterface.h ThreadInterface.h
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/api/: lwip_api_lib.c lwip_api_msg.c lwip_err.c lwip_netbuf.c lwip_netdb.c lwip_netifapi.c lwip_sockets.c lwip_tcpip.c
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/ppp/polarssl/: lwip_arc4.c lwip_des.c lwip_md4.c lwip_md5.c lwip_sha1.c
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/ppp/: lwip_auth.c lwip_ccp.c lwip_chap-md5.c lwip_chap-new.c lwip_chap_ms.c lwip_demand.c lwip_eap.c lwip_ecp.c lwip_eui64.c lwip_fsm.c lwip_ipcp.c lwip_ipv6cp.c lwip_lcp.c lwip_magic.c lwip_mppe.c lwip_multilink.c lwip_ppp.c lwip_pppapi.c lwip_pppcrypt.c lwip_pppoe.c lwip_pppol2tp.c lwip_pppos.c lwip_upap.c lwip_utils.c lwip_vj.c
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv4/: lwip_autoip.c lwip_dhcp.c lwip_etharp.c lwip_icmp.c lwip_igmp.c lwip_ip4.c lwip_ip4_addr.c lwip_ip4_frag.c
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/: lwip_def.c lwip_dns.c lwip_inet_chksum.c lwip_init.c lwip_ip.c lwip_mem.c lwip_memp.c lwip_netif.c lwip_pbuf.c lwip_raw.c lwip_stats.c lwip_sys.c lwip_tcp.c lwip_tcp_in.c lwip_tcp_out.c lwip_timeouts.c lwip_udp.c
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv6/: lwip_dhcp6.c lwip_ethip6.c lwip_icmp6.c lwip_inet6.c lwip_ip6.c lwip_ip6_addr.c lwip_ip6_frag.c lwip_mld6.c lwip_nd6.c
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/: lwip_ethernet.c lwip_ethernetif.c lwip_lowpan6.c
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/: lwip_random.c lwip_random.h lwip_tcp_isn.c lwip_tcp_isn.h
    ./mbed-os/features/FEATURE_LWIP/lwip-interface/: lwip_tools.cpp LWIPInterface.cpp LWIPInterfaceEMAC.cpp LWIPMemoryManager.cpp LWIPMemoryManager.h lwipopts.h LWIPStack.cpp LWIPStack.h ppp_lwip.cpp ppp_lwip.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/MAC/IEEE802_15_4/: mac_defines.h mac_fhss_callbacks.c mac_fhss_callbacks.h mac_filter.c mac_filter.h mac_header_helper_functions.c mac_header_helper_functions.h mac_indirect_data.c mac_indirect_data.h mac_mcps_sap.c mac_mcps_sap.h mac_mlme.c mac_mlme.h mac_pd_sap.c mac_pd_sap.h mac_security_mib.c mac_security_mib.h mac_timer.c mac_timer.h sw_mac.c sw_mac_internal.h
    ./mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
    ./mbed-os/: mbed.h
    ./mbed-os/rtos/TARGET_CORTEX/: mbed_boot.c mbed_rtos1_types.h mbed_rtos_storage.h mbed_rtx_conf.h mbed_rtx_handlers.c mbed_rtx_idle.cpp SysTimer.cpp SysTimer.h
    ./mbed-os/cmsis/: mbed_cmsis_conf.h RTE_Components.h
    ./mbed-os/targets/TARGET_Freescale/: mbed_rtx.h
    ./mbed-os/rtos/TARGET_CORTEX/TARGET_CORTEX_M/: mbed_rtx_fault_handler.c mbed_rtx_fault_handler.h
    ./mbed-os/features/frameworks/mbed-trace/source/: mbed_trace.c
    ./mbed-os/features/frameworks/mbed-trace/mbed-trace/: mbed_trace.h
    ./mbed-os/features/mbedtls/platform/src/: mbed_trng.c
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Mesh/: mesh.c mesh.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/MLE/: mle.c mle.h mle_tlv.c mle_tlv.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/mle_service/: mle_service.c mle_service_api.h mle_service_buffer.c mle_service_buffer.h mle_service_interface.c mle_service_interface.h mle_service_security.c mle_service_security.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/MPL/: mpl.c mpl.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/libNET/src/: multicast_api.c net_6lowpan_parameter_api.c net_ipv6.c net_load_balance.c net_load_balance_internal.h net_mle.c net_rpl.c net_short_address_extension.c net_test.c ns_net.c socket_api.c
    ./mbed-os/features/nanostack/nanostack-interface/: Nanostack.cpp Nanostack.h NanostackEthernetPhy.h NanostackInterface.h NanostackLockGuard.h NanostackPhy.h NanostackRfPhy.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/ND/: nd_defines.h nd_router_object.c nd_router_object.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/nd_proxy/: nd_proxy.c nd_proxy.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/Neighbor_cache/: neighbor_cache.c neighbor_table_definition.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Bootstraps/Generic/: network_lib.c protocol_6lowpan.c protocol_6lowpan_bootstrap.c protocol_6lowpan_interface.c
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Bootstraps/: network_lib.h protocol_6lowpan.h protocol_6lowpan_bootstrap.h protocol_6lowpan_interface.h
    ./mbed-os/features/frameworks/nanostack-libservice/source/libList/: ns_list.c
    ./mbed-os/features/frameworks/nanostack-libservice/source/nvmHelper/: ns_nvm_helper.c
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/SHA256_Lib/: ns_sha256.c shalib.c
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/: nsconfig.h
    ./mbed-os/features/frameworks/nanostack-libservice/source/nsdynmemLIB/: nsdynmemLIB.c
    ./mbed-os/features/nanostack/nanostack-hal-mbed-cmsis-rtos/nvm/: nvm_ram.c
    ./mbed-os/features/nvstore/source/: nvstore.cpp nvstore.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/NVM/: nwk_nvm.c nwk_nvm.h
    ./mbed-os/features/netsocket/cellular/: onboard_modem_api.h
    ./mbed-os/features/netsocket/cellular/generic_modem_driver/: OnboardCellularInterface.cpp OnboardCellularInterface.h PPPCellularInterface.cpp PPPCellularInterface.h UARTCellularInterface.cpp UARTCellularInterface.h
    ./mbed-os/rtos/TARGET_CORTEX/rtx5/Source/: os_systick.c os_tick_ptim.c
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/pan_blacklist/: pan_blacklist.c pan_blacklist_api.h
    ./mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/NWK_INTERFACE/Include/: protocol.h protocol_abstract.h protocol_stats.h protocol_timer.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/NWK_INTERFACE/: protocol_core.c protocol_core_sleep.c protocol_stats.c protocol_timer.c
    ./mbed-os/features/cellular/framework/targets/QUECTEL/BC95/: QUECTEL_BC95.cpp QUECTEL_BC95.h QUECTEL_BC95_CellularNetwork.cpp QUECTEL_BC95_CellularNetwork.h QUECTEL_BC95_CellularPower.cpp QUECTEL_BC95_CellularPower.h QUECTEL_BC95_CellularSIM.cpp QUECTEL_BC95_CellularSIM.h QUECTEL_BC95_CellularStack.cpp QUECTEL_BC95_CellularStack.h
    ./mbed-os/features/cellular/framework/targets/QUECTEL/BG96/: QUECTEL_BG96.cpp QUECTEL_BG96.h QUECTEL_BG96_CellularNetwork.cpp QUECTEL_BG96_CellularNetwork.h QUECTEL_BG96_CellularPower.cpp QUECTEL_BG96_CellularPower.h QUECTEL_BG96_CellularStack.cpp QUECTEL_BG96_CellularStack.h
    ./mbed-os/features/cellular/framework/targets/QUECTEL/UG96/: QUECTEL_UG96.cpp QUECTEL_UG96.h QUECTEL_UG96_CellularNetwork.cpp QUECTEL_UG96_CellularNetwork.h QUECTEL_UG96_CellularPower.cpp QUECTEL_UG96_CellularPower.h
    ./mbed-os/features/frameworks/mbed-client-randlib/source/: randLIB.c
    ./mbed-os/features/frameworks/mbed-client-randlib/mbed-client-randlib/: randLIB.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/MAC/: rf_driver_storage.c rf_driver_storage.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/RPL/: rpl_control.c rpl_control.h rpl_data.c rpl_data.h rpl_downward.c rpl_downward.h rpl_mrhof.c rpl_mrhof.h rpl_objective.c rpl_objective.h rpl_of0.c rpl_of0.h rpl_policy.c rpl_policy.h rpl_protocol.h rpl_structures.h rpl_upward.c rpl_upward.h
    ./mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Source/: rt_OsEventObserver.c rt_OsEventObserver.h rtx_core_c.h rtx_core_ca.h rtx_core_cm.h rtx_delay.c rtx_evflags.c rtx_evr.c rtx_kernel.c rtx_lib.c rtx_lib.h rtx_memory.c rtx_mempool.c rtx_msgqueue.c rtx_mutex.c rtx_semaphore.c rtx_system.c rtx_thread.c rtx_timer.c
    ./mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Config/: RTX_Config.c RTX_Config.h
    ./mbed-os/rtos/TARGET_CORTEX/rtx5/RTX/Include/: rtx_evr.h rtx_os.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Security/Common/: sec_lib.h sec_lib_definitions.h security_lib.c
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/MAC/serial/: serial_mac_api.c
    ./mbed-os/features/frameworks/mbed-coap/source/: sn_coap_builder.c sn_coap_header_check.c sn_coap_parser.c sn_coap_protocol.c
    ./mbed-os/features/frameworks/mbed-coap/mbed-coap/: sn_coap_header.h sn_coap_protocol.h sn_config.h
    ./mbed-os/features/frameworks/mbed-coap/source/include/: sn_coap_header_internal.h sn_coap_protocol_internal.h
    ./mbed-os/targets/TARGET_Freescale/TARGET_MCUXpresso_MCUS/TARGET_MCU_K64F/device/TOOLCHAIN_ARM_STD/: startup_MK64F12.S
    ./mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager/source/: storage_volume.cpp storage_volume_manager.cpp
    ./mbed-os/features/storage/FEATURE_STORAGE/storage-volume-manager/storage-volume-manager/: storage_volume_manager.h
    ./mbed-os/features/cellular/framework/targets/TELIT/HE910/: TELIT_HE910.cpp TELIT_HE910.h TELIT_HE910_CellularNetwork.cpp TELIT_HE910_CellularNetwork.h TELIT_HE910_CellularPower.cpp TELIT_HE910_CellularPower.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/6LoWPAN/Thread/: thread_address_registration_client.h thread_bbr_api.c thread_bbr_api_internal.h thread_beacon.c thread_beacon.h thread_bootstrap.c thread_bootstrap.h thread_border_router_api.c thread_border_router_api_internal.h thread_commissioning_api.c thread_commissioning_if.c thread_commissioning_if.h thread_common.c thread_common.h thread_config.h thread_constants.h thread_dhcpv6_client.c thread_dhcpv6_client.h thread_diagnostic.c thread_diagnostic.h thread_discovery.c thread_discovery.h thread_extension.h thread_extension_bbr.h thread_extension_bootstrap.h thread_host_bootstrap.c thread_host_bootstrap.h thread_joiner_application.c thread_joiner_application.h thread_leader_service.c thread_leader_service.h thread_lowpower_private_api.c thread_lowpower_private_api.h thread_management_api.c thread_management_client.c thread_management_client.h thread_management_if.c thread_management_internal.h thread_management_server.c thread_management_server.h thread_mdns.c thread_mdns.h thread_meshcop_lib.c thread_mle_message_handler.c thread_mle_message_handler.h thread_nd.c thread_nd.h thread_net_config_api.c thread_network_data_lib.c thread_network_data_lib.h thread_network_data_storage.c thread_network_data_storage.h thread_network_synch.c thread_network_synch.h thread_nvm_store.c thread_nvm_store.h thread_resolution_client.c thread_resolution_client.h thread_resolution_server.c thread_resolution_server.h thread_router_bootstrap.c thread_router_bootstrap.h thread_routing.c thread_routing.h thread_test_api.c thread_tmfcop_lib.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Security/TLS/: tls_ccm_crypt.c tls_ccm_crypt.h tls_lib.c tls_lib.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/Trickle/: trickle.c trickle.h
    ./mbed-os/features/cellular/framework/targets/UBLOX/PPP/: UBLOX_PPP.cpp UBLOX_PPP.h UBLOX_PPP_CellularNetwork.cpp UBLOX_PPP_CellularNetwork.h UBLOX_PPP_CellularPower.cpp UBLOX_PPP_CellularPower.h
    ./mbed-os/features/frameworks/unity/source/: unity.c
    ./mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
    ./mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_stack_trace.cpp utest_types.cpp
    ./mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/MAC/virtual_rf/: virtual_rf_client.c virtual_rf_defines.h virtual_rf_driver.c
    ./mbed-os/features/nanostack/sal-stack-nanostack/source/Service_Libs/whiteboard/: whiteboard.c whiteboard.h
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
